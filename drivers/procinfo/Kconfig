## drivers/procinfo/Kconfig
```kconfig
config PROCINFO
	bool "PROCINFO: Kernel Information"
	help 
		Provide kernel information to DECAF.
```
